# Keil uVision project Car Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Car Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source Group 1
    ./: Common.h ControlPins.c ControlPins.h CortexM.c CortexM.h led.c led.h main1.c motors.c motors.h switches.c switches.h SysTickTimer.c SysTickTimer.h Timer32.c Timer32.h TimerA.c TimerA.h uart.c uart.h ADC14.c ADC14.h
software components: CMSIS:CORE 5.4.0, Device:Startup 3.2.2
