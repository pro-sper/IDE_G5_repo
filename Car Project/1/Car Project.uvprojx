# Keil uVision project Car Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MSP432P4111 Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x01000000,0x00040000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Car Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x1000000 size 0x40000
  group Source Group 1
    ../: Timer32.c Timer32.h TimerA.c TimerA.h uart.c uart.h ADC14.c ADC14.h Common.h ControlPins.c ControlPins.h CortexM.c CortexM.h led.c led.h main1.c motors.c motors.h switches.c switches.h SysTickTimer.c SysTickTimer.h i2c.h i2c.c oled.h oled.c
software components: CMSIS:CORE 5.6.0, Device:Startup 3.2.2
